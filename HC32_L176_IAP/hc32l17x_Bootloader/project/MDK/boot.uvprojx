# Keil uVision project boot.uvprojx, settings and files
target hc32l17x_boot (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: HC32L176JATA HDSC
  pack: HDSC.HC32L17X.1.0.0
  cpu: IRAM(0x20000000,0x4000) IROM(0x00000000,0x20000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: iap +hex
  AfterMake: fromelf  --bin  -o ./output/release/iap.bin ./output/release/iap.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\source;..\..\driver;..\..\app;..\..\mcu\common;..\..\driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x2000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --keep=*Handler
  group common
    ./: startup_hc32l17x.s
    ../../mcu/common/: interrupts_hc32l17x.c system_hc32l17x.c
  group source
    ../source/: main.c
  group driver
    ../../driver/src/: ddl.c flash.c gpio.c lpm.c lpuart.c uart.c timer3.c sysctrl.c
  group iap
    ../../app/: modem.c iap.c
  group README
    ../: readme.txt
software components: CMSIS:CORE 5.0.1
