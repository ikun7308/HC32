# Keil uVision project APP.uvprojx, settings and files
target APP_Release (6070000::V6.7::.\ARMCLANG)
  device: HC32L176PATA HDSC
  pack: HDSC.HC32L17X.1.0.0
  cpu: IRAM(0x20000000,0x4000) IROM(0x00000000,0x20000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: APP +hex
  AfterMake: fromelf  --bin  -o ./output/release/APP.bin ./output/release/APP.axf
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: ..\..\mcu\common;..\source;..\..\driver\inc;..\app;..\app\DATA;..\app\FLASH;..\app\gsm_bsp;..\app\workmode;..\app;..\app\WBSENSOR;..\app\UART;..\app\ADC;..\app\DATA;..\app\DJ;..\app\DoorCheck;..\app\FLASH;..\app\GPIO;..\app\gsm_bsp;..\app\lpmode;..\app\MQTT;..\app\rtc;..\app\SYSCLOCK;..\app\TM1637;..\app;..\app\USER_BEEP;..\app\Screen_RS232;..\app\Upgrade;..\app\gsm_bsp;..\app\DJ;..\..\driver\src
  library: MicroLIB
  memory RVCT4: ROM 0x2000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --keep=*Handler
  group common
    ../../mcu/common/: interrupts_hc32l17x.c system_hc32l17x.c
    ./: startup_hc32l17x.s
  group source
    ../app/: main.c
  group driver
    ../../driver/src/: ddl.c flash.c gpio.c sysctrl.c lpm.c lpuart.c uart.c bt.c timer3.c wdt.c spi.c bgr.c
    ../app/: tim_3.c
    ../app/UART/: uart_init.c
    ../app/gsm_bsp/: GSM_BSP.C
  group README
    ../: readme.txt
software components: CMSIS:CORE 5.0.1
